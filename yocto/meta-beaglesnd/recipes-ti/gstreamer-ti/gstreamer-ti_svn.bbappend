FILES_${PN}-dev = "${libdir}/gstreamer-0.10/*.la"
FILES_${PN}-staticdev = "${libdir}/gstreamer-0.10/*.a"
